* This file is generated by the SEPIA on QSPICE v202.
Vbias N03 0   5.00000000e+00
Rdcr N03 N02   2.00001332e-03
Lout N02 SEPIA_MODEL_FITTING   4.98001407e-08
Resr 0 N01   2.01679264e-03
Cout N01 SEPIA_MODEL_FITTING   9.95980483e-05

Istep 0 SEPIA_MODEL_FITTING pwl 0 0   1.00000000e-03 0   1.00000100e-03  -2.00000000e+00
.TRAN 0   2.00000000e-03 0 10n
.PLOT TRAN V(SEPIA_MODEL_FITTING)
