* This file is generated by the SEPIA on QSPICE v202.
Vbias N03 0   3.30419480e+00
Rdcr N03 N02   1.43401578e-05
Lout N02 SEPIA_MODEL_FITTING   3.45485452e-07
Cout 0 SEPIA_MODEL_FITTING   1.90549433e-04

Rdump 0 SEPIA_MODEL_FITTING   6.56882907e-02
Iac 0 SEPIA_MODEL_FITTING AC 1
.AC DEC 49 10 100meg
.PLOT AC V(SEPIA_MODEL_FITTING)
