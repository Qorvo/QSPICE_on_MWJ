* This file is generated by the SEPIA on QSPICE v202.
Vbias N03 0   4.99995968e+00
Rdcr N03 N02   1.01254880e-06
Lout N02 SEPIA_MODEL_FITTING   5.02044019e-08
Cout 0 SEPIA_MODEL_FITTING   9.87820584e-05

Rdump 0 SEPIA_MODEL_FITTING   1.24456538e-01
Iac 0 SEPIA_MODEL_FITTING AC 1
.AC DEC 49 10 100meg
.PLOT AC V(SEPIA_MODEL_FITTING)
