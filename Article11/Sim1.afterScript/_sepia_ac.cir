* This file is generated by the SEPIA on QSPICE v202.
Vbias N03 0   5.00000000e+00
Rdcr N03 N02   2.00001332e-03
Lout N02 SEPIA_MODEL_FITTING   4.98001407e-08
Resr 0 N01   2.01679264e-03
Cout N01 SEPIA_MODEL_FITTING   9.95980483e-05

Iac 0 SEPIA_MODEL_FITTING AC 1
.AC DEC 49 10 100meg
.PLOT AC V(SEPIA_MODEL_FITTING)
